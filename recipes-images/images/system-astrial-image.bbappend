#################################################################################################################
## Intel Realsense
PACKAGECONFIG += "rsusb"
